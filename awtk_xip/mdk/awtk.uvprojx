# Keil uVision project awtk.uvprojx, settings and files
target awtk Sdram_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052:M7 NXP
  pack: NXP.iMXRT_DFP.1.0.2
  cpu: CPUTYPE("Cortex-M7") FPU2
  output: awtk.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NDEBUG,WITH_WCSXXX,SDRAM_MPU_INIT,CPU_MIMXRT1052DVL6A,APP_LCDIF_DATA_BUS=kELCDIF_DataBus16Bit,USE_GUI_MAIN,WITH_BITMAP_FONT
  c misc: --gnu
  c include: ../../../../../CMSIS/Include;../../../../../devices;..;../../../..;..\..\..\..\..\devices\MIMXRT1052\drivers;../../../../../devices/MIMXRT1052;../../../../../devices/MIMXRT1052/utilities/io;../../../../../devices/MIMXRT1052/utilities/str;../../../../../devices/MIMXRT1052/utilities/log;../../../../../devices/MIMXRT1052/utilities;..\..\..\..\..\middleware\awtk\src;..\..\..\..\..\middleware\awtk;..\awtk-port
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_sdram.scf
  link misc: --remove
  group source
    ../: awtk.c
  group startup
    ../../../../../devices/MIMXRT1052/: system_MIMXRT1052.c system_MIMXRT1052.h
    ../../../../../devices/MIMXRT1052/arm/: startup_MIMXRT1052.s
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group boot
    ../xip/: easyarm_flexspi_nor_config.c imxrt_boot_config.h
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_clock.c fsl_clock.h fsl_elcdif.c fsl_elcdif.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_pxp.c fsl_pxp.h fsl_common.c fsl_common.h fsl_lpi2c.c fsl_lpi2c.h
  group toucpanel
    ../: fsl_ft5406_rt.c fsl_ft5406_rt.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MIMXRT1052/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group awtk
    ../../../../../middleware/awtk/src/base/: array.c bitmap.c buffer.c button.c canvas.c check_button.c color.c dialog.c easing.c edit.c emitter.c enums.c event_queue.c events.c font.c font_manager.c fs.c group_box.c idle.c image.c image_loader.c image_manager.c label.c layout.c lcd.c locale.c main_loop.c matrix.c mem.c progress_bar.c rect.c resource_manager.c slider.c str.c system_info.c time.c timer.c theme.c utf8.c utils.c value.c vgcanvas.c view.c widget.c widget_animator.c widget_vtable.c window.c window_animator.c window_manager.c wstr.c
    ../../../../../middleware/awtk/src/: tk.c
    ../../../../../middleware/awtk/src/blend/: blend_image_565_565.c blend_image_565_8888.c blend_image_8888_565.c blend_image_8888_8888.c soft_g2d.c
    ../../../../../middleware/awtk/src/lcd/: lcd_mem_rgb565.c
    ../../../../../middleware/awtk/src/vgcanvas/: vgcanvas_null.c
    ../../../../../middleware/awtk/src/ui_loader/: ui_builder.c ui_builder_default.c ui_builder_writer.c ui_loader.c ui_loader_default.c ui_loader_xml.c
    ../../../../../middleware/awtk/src/xml/: xml_builder.c xml_parser.c
    ../../../../../middleware/awtk/src/window_animators/: window_animator_fb.c
    ../../../../../middleware/awtk/src/main_loop/: main_loop_simple.c
    ../../../../../middleware/awtk/src/platforms/raw/: mutex.c
    ../../../../../middleware/awtk/src/font/: font_bitmap.c
  group awtk-port
    ../awtk-port/: platform.c lcd_support.c lcd_support.h main_loop_rt1052_raw.c
  group awtk-demos
    ../../../../../middleware/awtk/demos/: demo_main.c demo_ui_app.c resource.c
target awtk_Sdram_release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052:M7 NXP
  pack: NXP.iMXRT_DFP.1.0.2
  cpu: CPUTYPE("Cortex-M7") FPU2
  output: elcdif_rgb.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SDRAM_MPU_INIT, CPU_MIMXRT1052DVL6A, APP_LCDIF_DATA_BUS=kELCDIF_DataBus16Bit
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../CMSIS/Include;../../../../../../devices;..;../../../..;../../../../../../devices/MIMXRT1052/drivers;../../../../../../devices/MIMXRT1052;../../../../../../devices/MIMXRT1052/utilities/io;../../../../../../devices/MIMXRT1052/utilities/str;../../../../../../devices/MIMXRT1052/utilities/log;../../../../../../devices/MIMXRT1052/utilities
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_sdram.scf
  link misc: --remove
